
PRINC = "1"

FILESEXTRAPATHS := "${THISDIR}/${PN}"

SRC_URI_append = " file://defconfig "

