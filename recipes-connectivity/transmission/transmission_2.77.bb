require transmission.inc

SRC_URI[md5sum] = "60c0e77a1852656215f7102a437b2a3d"
SRC_URI[sha256sum] = "55b1653fc18a10153ba9439f284bd7b2276a6859416dcae217d9e8c689841fde"
